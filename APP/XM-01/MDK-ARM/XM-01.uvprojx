# Keil uVision project XM-01.uvprojx, settings and files
target XM-01 (5050106::V5.05 update 1 (build 106)::ARMCC)
  device: STM32F405RGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: APP_V131 +hex
  AfterMake: fromelf --bincombined -o "$L@L.bin" "#L"
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F405xx
  c misc: --no_unaligned_access
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../Middlewares/Third_Party/RealThread_RTOS_RT-Thread/include/libc/include;../Middlewares/Third_Party/SEGGER_RTT_Viewer/RTT;../X-CUBE-AI/App;../Middlewares/ST/AI/Inc;../Drivers/BSP/Inc;../X-CUBE-AI-NEW/App
  library: MicroLIB
  memory RVCT4: ROM 0x8040000 size 0x60000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  scatter file: ..\XM-01.sct
  group Application/MDK-ARM
    ./: startup_stm32f405xx.s
  group Application/User/Core
    ../Core/Src/: myEdge_ai_app.c mySensor_deal.c myOutput_deal.c protocol_parser.c myFlash.c ai_model_wrapper.c jq260_hybrid_lr_model.c main.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Core/Src/: stm32f4xx_hal_msp.c
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Middlewares/RTTViewer
    ../Middlewares/Third_Party/SEGGER_RTT_Viewer/RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
  group Middlewares/RT-Thread/RTOS/shell
    ../Middlewares/Third_Party/RealThread_RTOS_RT-Thread/components/finsh/src/: cmd.c msh.c msh_file.c msh_parse.c shell.c
  group Middlewares/RT-Thread/RTOS/libcpu
    ../Middlewares/Third_Party/RealThread_RTOS_RT-Thread/libcpu/arm/cortex-m4/: context_rvds.S cpuport.c
  group Middlewares/RT-Thread/RTOS/kernel
    ../Middlewares/Third_Party/RealThread_RTOS_RT-Thread/src/: clock.c components.c cpu.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c signal.c slab.c thread.c timer.c
    ../Middlewares/Third_Party/RealThread_RTOS_RT-Thread/bsp/_template/cubemx_config/: board.c
  group Drivers/BSP
    ../Core/Src/: stm32f4xx_it.c
    ../Drivers/BSP/Src/: dma.c gpio.c usart.c
  group X-CUBE-AI
    ../X-CUBE-AI-NEW/App/: network.c network_data.c network_data_params.c
  group Lib
    ../Middlewares/ST/AI/Lib/: NetworkRuntime1020_CM4_Keil.lib
  group Application/User/X-CUBE-AI/App
    ./: 
    ../X-CUBE-AI/App/: network.c network_data.c network_data_params.c
  group Doc
    ./: 
    ../X-CUBE-AI/App/: network_generate_report.txt
